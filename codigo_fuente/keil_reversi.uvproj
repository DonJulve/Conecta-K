# Keil uVision project keil_reversi.uvproj, settings and files
target Simulator (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC2105 NXP
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x1FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: keil_reversi
  c flags: Optim=4 oTime=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x40000000 size 0x8000
  group Startup Code
    ./: Startup.s
  group System Calls
    ./: Retarget.c
  group Source Code
    ./: main.c gpio_hal.h gpio_hal.c eventos.h FIFO.h FIFO.c io_reserva.h planificador.c planificador.h temporizador_hal.h temporizador_hal.c temporizador_drv.h temporizador_drv.c hello_world.c hello_world.h power_hal.c power_hal.h pruebas.c pruebas.h Gestor_alarmas.h Gestor_alarmas.c int_ext_hal.h int_ext_hal.c int_ext_drv.c int_ext_drv.h visualizar.h visualizar.c SWI.s juego.h juego.c llamadas_sistema.h WDT_hal.h WDT_hal.c linea_serie_hal.h linea_serie_hal.c linea_serie_drv.h linea_serie_drv.c celda.h entrada.h entrada.c conecta_K_buscar_alineamiento_arm.s conecta_K_buscar_alineamiento_arm_op.s conecta_K_hay_linea_arm_arm.s conecta_K_hay_linea_arm_arm_op.s conecta_K_hay_linea_arm_c.s tablero.h conecta_K_2023.h conecta_K_2023.c tablero_test.h tablero.c
